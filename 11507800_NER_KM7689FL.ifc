Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-07T17:19:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 07 17:19:18 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\936bd223-ad55-45cc-bf8d-746db16fa54e\01774658-08d0-49f3-a231-df12e136618d\ifc * Database version: 5507 * Database creation date: Tue Feb 07 17:19:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 07 17:19:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 07 17:19:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11507800_NER_KM7689FL:26768970_NER_11507800_KM7689FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26768970_NER_11507800_KM7689FL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26768970_NER_11507800_KM7689FL
Type - Pset_ProvisionForVoid - Width: 916 mm; Height: 51 mm; Depth: 408 mm
Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - sets with these values: 2
